# Keil uVision project STM32_StandardLibrary.uvprojx, settings and files
target STM32_StandardLibrary (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_StandardLibrary
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\Main;..\User\Usart;..\User\Find_Num;..\User\GeneralTimer_3;..\User\TB6612
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/Main/: main.c stm32f10x_it.c
    ../User/Usart/: Usart.c
    ../User/Find_Num/: Find_Num.c
    ../User/GeneralTimer_3/: GeneralTimer_3.c
    ../User/TB6612/: TB6612.c
  group DOC
    ../Doc/: 工程说明.txt
